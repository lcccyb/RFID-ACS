# Keil uVision project IC_RC522.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89LE52RC STC89LE51RC Series
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: IC_RC522 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../code/: main.c ctrl.c rc522.c timer.c uart.c lcd12864.c beep.c key.c EEPROM.C
